# Keil uVision project keil_reversi.uvproj, settings and files
target Simulator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: keil_reversi
  c flags: Optim=4 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s
  group Header
    ./: celda.h cola.h eventos.h gestor_alarmas.h gestor_energia.h gpio_control.h sudoku_2021.h tableros.h temporizador.h boton.h gestor_pulsacion.h Gestor_IO.h sudoku_p2.h constantes_comunes.h
  group C
    ./: cola.c gestor_alarmas.c gestor_energia.c gpio_control.c sudoku_2021.c temporizador.c testAll.c boton.c gestor_pulsacion.c Gestor_IO.c sudoku_p2.c
